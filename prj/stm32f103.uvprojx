# Keil uVision project stm32f103.uvprojx, settings and files
target stm32f103 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c misc: --c99
  c include: ..\src\app;..\src\raw-os\kernel\include;..\src\raw-os\port;..\src\raw-os\kernel\extension\include;..\src\stm32f103;..\src\stm32f103\driver\inc;..\src\lib;..\src\cli;..\src\app\key;..\src\app\pub
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../src/app/: main.c sys_init.c sys_led.c sys_uart.c debug_uart.c
    ../src/app/key/: key.c
    ../src/app/pub/: pub.c
  group config
    ../src/raw-os/kernel/include/: raw_config.h
    ../src/cli/: cli_config.h
  group stm32f103
    ../src/stm32f103/: core_cm3.c startup_stm32f10x_hd.s stm32f10x_it.c system_stm32f10x.c
  group driver
    ../src/stm32f103/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group raw-os
    ../src/raw-os/kernel/: raw_block.c raw_byte.c raw_event.c raw_idle.c raw_idle_event.c raw_mqueue.c raw_mutex.c raw_obj.c raw_pend.c raw_queue.c raw_queue_buffer.c raw_queue_size.c raw_sched.c raw_sem.c raw_stat.c raw_stm.c raw_system.c raw_task.c raw_task_0.c raw_task_queue_size.c raw_task_sem.c raw_tick.c raw_timer.c
  group port
    ../src/raw-os/port/: cpu.asm port.c port_hook.c raw_trace_port.c
  group raw-os-extension
    ../src/raw-os/: user_extension.c
    ../src/raw-os/kernel/extension/lib/: simple_printf.c
  group lib
    ../src/lib/: serial_fifo.c
    ../src/raw-os/kernel/extension/lib/: fifo.c
  group cli
    ../src/cli/: cli.c cli_port.c cli_readline.c cli_simple.c cmds.c command.c
software components: CMSIS:CORE 4.1.0
