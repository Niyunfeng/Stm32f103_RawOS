# Keil uVision project stm32f103.uvproj, settings and files
target stm32f103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103 +hex
  c flags: Optim=1
  c misc: --c99
  c include: ..\src\app;..\src\raw-os\kernel\include;..\src\raw-os\port;..\src\raw-os\kernel\extension\include;..\src\stm32f103;..\src\stm32f103\driver\inc;..\src\lib;..\src\cli;..\src\app\key;..\src\app\pub
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../src/app/: main.c sys_init.c sys_led.c debug_uart.c
    ../src/app/key/: key.c
    ../src/app/pub/: pub.c
  group config
    ../src/raw-os/kernel/include/: raw_config.h
    ../src/cli/: cli_config.h
  group stm32f103
    ../src/stm32f103/: core_cm3.c startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
  group driver
    ../src/stm32f103/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group raw-os
    ../src/raw-os/kernel/: raw_block.c raw_byte.c raw_event.c raw_idle.c raw_idle_event.c raw_mqueue.c raw_mutex.c raw_obj.c raw_pend.c raw_queue.c raw_queue_buffer.c raw_queue_size.c raw_sched.c raw_sem.c raw_stat.c raw_stm.c raw_system.c raw_task.c raw_task_0.c raw_task_queue_size.c raw_task_sem.c raw_tick.c raw_timer.c
  group port
    ../src/raw-os/port/: cpu.asm port.c port_hook.c raw_trace_port.c
  group raw-os-extension
    ../src/raw-os/: user_extension.c
    ../src/raw-os/kernel/extension/lib/: simple_printf.c
  group lib
    ../src/lib/: serial_fifo.c
  group cli
    ../src/cli/: cli.c cli_port.c cli_readline.c cli_simple.c cmds.c command.c
